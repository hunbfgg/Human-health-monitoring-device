# Keil uVision project Healthy.uvprojx, settings and files
target Healthy (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Healthy +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\USMART;..\HARDWARE\SIM900A;..\HARDWARE\TIMER;..\HARDWARE\DS18B20;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\USART2;..\HARDWARE\TEXT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MPU6050/: mpuiic.c mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TEXT/: text.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c
  group README
    ../: README.TXT
